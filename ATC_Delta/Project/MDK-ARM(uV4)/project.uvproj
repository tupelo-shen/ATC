# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,STM32_F4,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User\fonts;..\..\emWin\GUI_X;..\..\emWin\Config;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\uC-LIB;..\..\uCOS-III\uCOS-III\Ports;..\..\uCOS-III\uCOS-III\Source;..\..\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\User\fatfs\src;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\User\usbh_mass_storage;..\..\User\usbd_mass_storage;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\Libraries\STM32F4x7_ETH_Driver;..\..\User\uIP\http;..\..\User\uIP\uip;..\..\User\uIP\dm9000;..\..\User\LwIP\lwip_v1.3.2\port\STM32F4x7\Standalone;..\..\User\LwIP\lwip_v1.3.2\src\include\ipv4;..\..\User\LwIP\lwip_v1.3.2\src\include\lwip;..\..\User\LwIP\lwip_v1.3.2\src\include\netif;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\User\LwIP\lwip_v1.3.2\port\STM32F4x7;..\..\User\LwIP;..\..\User\LwIP\lwip_v1.3.2\src\include;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c os_cfg_app.h app_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c
  group BSP
    ../../User/bsp_stm32f4xx/: bsp.c bsp.h bsp_os.c
    ../../User/bsp_stm32f4xx/src/: bsp_wm8978.c bsp_ad7606.c bsp_bh1750.c bsp_bmp085.c bsp_camera.c bsp_cpu_flash.c bsp_eeprom_24xx.c bsp_fsmc_sram.c bsp_hmc5883l.c bsp_i2c_gpio.c bsp_key.c bsp_led.c bsp_mpu6050.c bsp_nand_flash.c bsp_nor_flash.c bsp_printf.c bsp_sdio_sd.c bsp_si4730.c bsp_spi_flash.c bsp_uart.c bsp_rtc.c bsp_tim_pwm.c bsp_spi_bus.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_spi.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_dcmi.c stm32f4xx_adc.c stm32f4xx_flash.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group LCD_Driver
    ../../emWin/DisplayDriver/: GUIDRV_Template.c
    ../../User/bsp_stm32f4xx/src/: bsp_touch.c LCD_RA8875.c LCD_SPFD5420.c bsp_tft_lcd.c bsp_ra8875_flash.c bsp_ra8875_port.c param.c bsp_gt811.c LCD_ILI9488.c bsp_tsc2046.c bsp_ts_ft5x06.c
  group fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hz24.c hz32.c SimSun_1616.c SimSun_13.c SimSun_2424.c ra8875_asc_width.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_Ex.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/DEMO
    ../../emWin/emWinTask/: MainTask.c MainTask.h App_DispPic.c App_Recorder.c App_Sensor.c App_3D.c App_Radio.c App_Settings.c App_AD7606.c App_Camera.c App_Net.c App_FileBrowse.c App_HardDisk.c App_SysFunction.c App_SysIcon.c
  group GUI/Lib
    ../../emWin/GUILib/: STemWin528_CM4_OS_Keil_ot.lib
  group uC/CPU
    ../../uCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../uCOS-III/uC-LIB/: lib_str.h lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c
    ../../uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group FatFS
    ../../User/fatfs/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../../User/fatfs/src/option/: syscall.c
  group USB HOST Drive
    ../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB OTG  Drive
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c usb_dcd.c usb_dcd_int.c
  group USBH Masss Storage
    ../../User/usbh_mass_storage/: usb_bsp.c usb_conf.h usbh_bsp_msc.h usbh_conf.h usbh_it.c usbh_usr.c usbh_usr.h
  group USB DEVICE Drive
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USBD Mass Storage
    ../../User/usbd_mass_storage/: usbd_conf.h usbd_desc.c usbd_desc.h usbd_storage_msd.c usbd_usr.c
  group UIP
    ../../User/uIP/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group UIP-DM9000
    ../../User/uIP/dm9000/: clock-arch.c dm9k_uip.c tapdev.c
  group UIP-HTTP
    ../../User/uIP/http/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c
  group STM32F4x7_ETH_Driver
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group LwIP
    ../../User/LwIP/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
    ../../User/LwIP/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../User/LwIP/lwip_v1.3.2/src/core/: memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c dns.c init.c mem.c
    ../../User/LwIP/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../User/LwIP/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
  group LwIP-HTTP
    ../../User/LwIP/: fs.c httpd_cgi_ssi.c httpd_w.c netconf.c stm32f4x7_eth_bsp.c
  group Doc
    ../../Doc/: 01.例程操作和功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
target CpuRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output
  AfterMake: CopyHex_CpuRAM.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,__CC_ARM,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\bsp;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
target ExtSRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: output +hex
  AfterMake: CopyHex_ExtSRAM.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000200 size 0xffe00
